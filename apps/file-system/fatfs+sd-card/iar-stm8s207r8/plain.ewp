# IAR project plain.ewp, settings and files
configuration spi (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: ..\..\..\..\devices\sd-card\sd-card\src\dev\; ..\src\; ..\src\fatfs\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\middlewares\fatfs\source\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../src/: fatfs-drv.h fatfs-spi-drv.c main.c
    ../../../../platform/: platform.h
  group Project/cpu
    ../../../../cpu/stm8s207r8/: compiler-def.h cpu.h stm8.h
  group Project/dev
    ../../../../devices/sd-card/sd-card/src/dev/: hal-sd-spi.h sd-spi.c sd-spi.h
  group Project/middlewares/fatfs
    ../../../../3rd-party/middlewares/fatfs/source/: ff.c
  group Project/middlewares/fatfs/port
    ../src/fatfs/: diskio.c
  group Project/platform
    ../../../../platform/stm8s207r8/: platform.c
  group Project/platform/dev
    ../../../../devices/sd-card/sd-card/src/platform/stm8s207r8/dev/: hal-sd-spi.c
