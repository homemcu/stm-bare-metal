# IAR project lwip-freertos.ewp, settings and files
configuration ping (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; LWIP_FREERTOS
  ICCARM.CCIncludePath2: ..\..\..\..\devices\ethernet-uip\lan8720\src\dev\; ..\src\; ..\src\lwip\; ..\src\lwip\port\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\platform\stm32f407zg\freertos\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F4xx\Include; ..\..\..\..\3rd-party\middlewares\lwip\src\include\; ..\..\..\..\3rd-party\middlewares\lwip\src\include\lwip\; ..\..\..\..\3rd-party\middlewares\lwip\src\include\netif\; ..\..\..\..\3rd-party\middlewares\freertos\include\; ..\..\..\..\3rd-party\middlewares\freertos\portable\IAR\ARM_CM4F\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\platform\stm32f407zg\freertos\
  ILINK.IlinkOutputFile: lwip-freertos.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../src/: eth-lwip-drv.h eth-lwip-freertos.c eth-lwip-lan8720-drv.c main.c
  group Project/cpu
    ../../../../cpu/stm32f407zg/: compiler-def.h cpu.h stm32f4xx-hw.c stm32f4xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Project/dev
    ../../../../devices/ethernet-uip/lan8720/src/dev/: hal-lan8720-rmii.h lan8720-regs.h mac.h
  group Project/middlewares/freertos
    ../../../../platform/stm32f407zg/freertos/: FreeRTOSConfig.h
    ../../../../3rd-party/middlewares/freertos/portable/MemMang/: heap_4.c
    ../../../../3rd-party/middlewares/freertos/: list.c queue.c tasks.c
  group Project/middlewares/freertos/cortex-m4f
    ../../../../3rd-party/middlewares/freertos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Project/middlewares/lwip/api
    ../../../../3rd-party/middlewares/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Project/middlewares/lwip/core
    ../../../../3rd-party/middlewares/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Project/middlewares/lwip/core/ipv4
    ../../../../3rd-party/middlewares/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Project/middlewares/lwip/netif
    ../../../../3rd-party/middlewares/lwip/src/netif/: ethernet.c
  group Project/middlewares/lwip/port
    ../src/lwip/: ethernetif.c ethernetif.h lwipopts.h
    ../src/lwip/port/: sys_arch.c
  group Project/platform
    ../../../../platform/stm32f407zg/: platform-freertos.c
  group Project/platform/dev
    ../../../../devices/ethernet-uip/lan8720/src/platform/stm32f407zg/dev/: hal-lan8720-rmii.c
