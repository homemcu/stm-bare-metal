# IAR project plain.ewp, settings and files
configuration uvc-otghs-ov7670 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS
  ICCARM.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\devices\usb-device\src\dev\; ..\..\..\..\devices\camera\ov7670\src\dev\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F7xx\Include; ..\..\..\..\3rd-party\drivers\libusb_stm32\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../src/: imgsensor-drv.h imgsensor-ov7670-drv.c main.c project-conf.h uvc-camera.c uvc-camera.h
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Project/dev
    ../../../../devices/camera/ov7670/src/dev/: hal-imgsensor-dcmi.h hal-imgsensor-i2c.h ov7670-cmds.h ov7670.h
    ../src/dev/: ov7670.c
  group Project/middlewares/libusb
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_core.c
  group Project/middlewares/libusb/dev
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_stm32f746_otghs.c
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
  group Project/platform/dev
    ../../../../devices/camera/ov7670/src/platform/stm32f746ig/dev/: hal-imgsensor-dcmi.c hal-imgsensor-i2c.c
    ../../../../devices/usb-device/src/platform/stm32f746ig/dev/: usbd-hw-init.c
