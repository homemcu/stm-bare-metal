# IAR project plain.ewp, settings and files
configuration cdc-rndis-uip-otgfs (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGFS; UIP_EXAMPLE_HELLO_WORLD
  ICCARM.CCIncludePath2: ..\src\; ..\src\uip\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\devices\usb-device\src\dev\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F7xx\Include; ..\..\..\..\3rd-party\drivers\libusb_stm32\inc\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\hello-world\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration cdc-rndis-uip-otghs-fs (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS_FS; UIP_EXAMPLE_HELLO_WORLD
configuration cdc-rndis-uip-otghs (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS; UIP_EXAMPLE_HELLO_WORLD
  group Project
    ../src/: eth-uip-drv.h eth-uip-plain.c eth-uip-rndis-drv.c eth.h main.c project-conf.h usb-cdc-rndis.c usb-cdc-rndis.h
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Project/middlewares/libusb
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_core.c
  group Project/middlewares/libusb/dev
    ../../../../devices/usb-device/src/platform/stm32f746ig/dev/: usbd-hw-init.c
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_stm32f746_otgfs.c usbd_stm32f746_otghs.c
  group Project/middlewares/uip
    ../../../../3rd-party/middlewares/uip/: psock.c timer.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group Project/middlewares/uip/apps/hello-world
    ../../../../3rd-party/middlewares/uip/apps/hello-world/: hello-world.c
  group Project/middlewares/uip/port
    ../src/uip/: clock-arch.c clock-arch.h uip-conf.h
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
