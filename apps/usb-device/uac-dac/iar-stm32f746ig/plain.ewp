# IAR project plain.ewp, settings and files
configuration uac-otgfs-spi-i2s (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; UART_TERMINAL=1; USBD_OTGFS
  ICCARM.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\devices\usb-device\src\dev\; ..\..\..\..\devices\audio-out\i2s\src\dev\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F7xx\Include; ..\..\..\..\3rd-party\drivers\libusb_stm32\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration uac-otgfs-sai-i2s (ARM, debug)
  as the first configuration, except:
configuration uac-otghs-fs-spi-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; UART_TERMINAL=1; USBD_OTGHS_FS
configuration uac-otghs-fs-sai-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
configuration uac2-otghs-spi-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; UART_TERMINAL=1; USBD_OTGHS
  ICCARM.CCOptStrategy: 1
configuration uac2-otghs-sai-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; UART_TERMINAL=1; USBD_OTGHS
  group Project
    ../src/: main.c project-conf.h uac-dac-drv.h uac-dac-sai-i2s-drv.c uac-dac-spi-i2s-drv.c usb-uac-i2s.c usb-uac-i2s.h usb-uac2-i2s.c
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Project/dev
    ../src/dev/: hal-i2s-mclk.h
    ../../../../devices/audio-out/i2s/src/dev/: hal-sai-i2s.h hal-spi-i2s.h
    ../../../../devices/usb-device/src/dev/: usb-uac.h usb-uac2.h usbd-hw-init.h
  group Project/middlewares/libusb
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_core.c
  group Project/middlewares/libusb/dev
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_stm32f746_otgfs.c usbd_stm32f746_otghs.c
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
  group Project/platform/dev
    ../src/platform/stm32f746ig/dev/: hal-i2s-mclk.c
    ../../../../devices/audio-out/i2s/src/platform/stm32f746ig/dev/: hal-sai-i2s.c hal-spi-i2s.c
    ../../../../devices/usb-device/src/platform/stm32f746ig/dev/: usbd-hw-init.c
