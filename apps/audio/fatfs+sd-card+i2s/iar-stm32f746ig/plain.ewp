# IAR project plain.ewp, settings and files
configuration sd-sdmmc-spi-i2s (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; DUART_TERMINAL=1
  ICCARM.CCIncludePath2: ..\src\; ..\src\fatfs\; ..\..\..\..\devices\sd-card\sd-card\src\dev\; ..\..\..\..\devices\audio-out\i2s\src\dev\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F7xx\Include; ..\..\..\..\3rd-party\middlewares\fatfs\source\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sd-spi-spi-i2s (ARM, debug)
  as the first configuration, except:
configuration sd-sdmmc-sai-i2s (ARM, debug)
  as the first configuration, except:
configuration sd-spi-sai-i2s (ARM, debug)
  as the first configuration, except:
  group Project
    ../src/: audio-out-drv.h audio-out-sai-i2s-drv.c audio-out-spi-i2s-drv.c fatfs-drv.h fatfs-sdmmc-drv.c fatfs-spi-drv.c main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Project/dev
    ../../../../devices/audio-out/i2s/src/dev/: hal-sai-i2s.h hal-spi-i2s.h
    ../../../../devices/sd-card/sd-card/src/dev/: hal-sd-sdmmc.h hal-sd-spi.h sd-defs.h sd-spi.c sd-spi.h sd.h
  group Project/middlewares/fatfs
    ../../../../3rd-party/middlewares/fatfs/source/: ff.c
  group Project/middlewares/fatfs/port
    ../src/fatfs/: diskio.c
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
  group Project/platform/dev
    ../../../../devices/audio-out/i2s/src/platform/stm32f746ig/dev/: hal-sai-i2s.c hal-spi-i2s.c
    ../../../../devices/sd-card/sd-card/src/platform/stm32f746ig/dev/: hal-sd-sdmmc.c hal-sd-spi.c
