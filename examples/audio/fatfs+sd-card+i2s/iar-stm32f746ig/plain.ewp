# IAR project plain.ewp, settings and files
configuration sd-sdmmc-spi-i2s (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; DUART_TERMINAL=1
  ICCARM.CCIncludePath2: ..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\audio-out\; ..\..\..\..\drv\sd-card\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f7\Include; ..\..\..\..\3rd-party\middlewares\fatfs\source\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sd-spi-spi-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\audio-out\; ..\..\..\..\drv\sd-card\; ..\..\..\..\drv\sd-card\sd-spi\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f7\Include; ..\..\..\..\3rd-party\middlewares\fatfs\source\
configuration sd-sdmmc-sai-i2s (ARM, debug)
  as the first configuration, except:
configuration sd-spi-sai-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  group Project
    ../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/: system_stm32f7xx.c
  group Project/drv
    ../../../../drv/audio-out/: audio-out-sai-i2s-drv.c audio-out-spi-i2s-drv.c
    ../../../../drv/sd-card/: fatfs-sdmmc-drv.c fatfs-spi-drv.c
    ../../../../drv/sd-card/sd-spi/: sd-spi.c
  group Project/hal
    ../../../../hal/src/stm32f746ig/: hal-sai-i2s.c hal-sd-sdmmc.c hal-sd-spi.c hal-spi-i2s.c
  group Project/middlewares/fatfs
    ../../../../3rd-party/middlewares/fatfs/source/: ff.c
  group Project/middlewares/fatfs/port
    ../../../../lib/fatfs/: diskio.c
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
