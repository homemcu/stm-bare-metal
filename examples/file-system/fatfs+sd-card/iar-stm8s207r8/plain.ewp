# IAR project plain.ewp, settings and files
configuration spi (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: ..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\sd-card\; ..\..\..\..\drv\sd-card\sd-spi\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\middlewares\fatfs\source\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../src/: main.c
    ../../../../platform/: platform.h
  group Project/cpu
    ../../../../cpu/stm8s207r8/: compiler-def.h cpu.h stm8.h
  group Project/drv
    ../../../../drv/sd-card/: fatfs-spi-drv.c
    ../../../../drv/sd-card/sd-spi/: sd-spi.c
  group Project/hal
    ../../../../hal/src/stm8s207r8/: hal-sd-spi.c
  group Project/middlewares/fatfs
    ../../../../3rd-party/middlewares/fatfs/source/: ff.c
  group Project/middlewares/fatfs/port
    ../../../../lib/fatfs/: diskio.c
  group Project/platform
    ../../../../platform/stm8s207r8/: platform.c
