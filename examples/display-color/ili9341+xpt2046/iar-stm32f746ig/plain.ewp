# IAR project plain.ewp, settings and files
configuration spi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; ILI9341_SPI; UART_TERMINAL=1
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\color-scr\; ..\..\..\..\drv\color-scr\ili9341\; ..\..\..\..\drv\touch\; ..\..\..\..\drv\touch\xpt2046\; ..\..\..\..\lib\screen\; ..\..\..\..\lib\screen\color-scr\; ..\..\..\..\lib\touch\; ..\..\..\..\lib\fonts\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f7\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration fmc (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; ILI9341_8080I; UART_TERMINAL=1
  group Project
    ../../src/: main-touch.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/: system_stm32f7xx.c
  group Project/drv
    ../../../../drv/color-scr/: color-scr-ili9341-drv.c
    ../../../../drv/color-scr/ili9341/: ili9341.c
    ../../../../drv/touch/: touch-xpt2046-drv.c
    ../../../../drv/touch/xpt2046/: xpt2046.c
  group Project/hal
    ../../../../hal/src/stm32f746ig/: hal-ili9341-4line-spi.c hal-ili9341-8080I-16bit-fmc.c hal-xpt2046-soft-spi.c
  group Project/lib
    ../../../../lib/screen/color-scr/: color-scr.c
    ../../../../lib/fonts/: fonts.c
    ../../../../lib/touch/: touch.c
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
