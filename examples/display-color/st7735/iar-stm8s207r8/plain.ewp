# IAR project plain.ewp, settings and files
configuration spi (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\color-scr\; ..\..\..\..\drv\color-scr\st7735\; ..\..\..\..\lib\screen\; ..\..\..\..\lib\screen\color-scr\; ..\..\..\..\lib\fonts\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm8s207r8/: compiler-def.h cpu.h stm8.h
  group Project/drv
    ../../../../drv/color-scr/: color-scr-st7735-drv.c
    ../../../../drv/color-scr/st7735/: st7735.c
  group Project/hal
    ../../../../hal/src/stm8s207r8/: hal-st7735-4line-spi.c
  group Project/lib
    ../../../../lib/screen/color-scr/: color-scr.c
    ../../../../lib/fonts/: fonts.c
  group Project/platform
    ../../../../platform/stm8s207r8/: platform.c
