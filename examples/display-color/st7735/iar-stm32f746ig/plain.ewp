# IAR project plain.ewp, settings and files
configuration spi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\color-scr\; ..\..\..\..\drv\color-scr\st7735\; ..\..\..\..\lib\screen\; ..\..\..\..\lib\screen\color-scr\; ..\..\..\..\lib\fonts\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f7\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/: system_stm32f7xx.c
  group Project/drv
    ../../../../drv/color-scr/: color-scr-st7735-drv.c
    ../../../../drv/color-scr/st7735/: st7735.c
  group Project/hal
    ../../../../hal/src/stm32f746ig/: hal-st7735-4line-spi.c
  group Project/lib
    ../../../../lib/screen/color-scr/: color-scr.c
    ../../../../lib/fonts/: fonts.c
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
