# IAR project uip-freertos.ewp, settings and files
configuration hello-world (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; UIP_EXAMPLE_HELLO_WORLD
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\hal\inc\hal-lan8720-rmii\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\lan8720\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\platform\stm32f407zg\freertos\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f4\Include; ..\..\..\..\3rd-party\middlewares\freertos\include\; ..\..\..\..\3rd-party\middlewares\freertos\portable\IAR\ARM_CM4F\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\hello-world\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\platform\stm32f407zg\freertos\
  OBJCOPY.OOCOutputFile: uip-freertos.hex
  ILINK.IlinkOutputFile: uip-freertos.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration dhcpc (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; UIP_EXAMPLE_DHCPC
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\hal\inc\hal-lan8720-rmii\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\lan8720\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\platform\stm32f407zg\freertos\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f4\Include; ..\..\..\..\3rd-party\middlewares\freertos\include\; ..\..\..\..\3rd-party\middlewares\freertos\portable\IAR\ARM_CM4F\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\dhcpc\; ..\..\..\..\3rd-party\middlewares\uip\apps\telnetd\
configuration telnetd (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; UIP_EXAMPLE_TELNETD
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\hal\inc\hal-lan8720-rmii\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\lan8720\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\platform\stm32f407zg\freertos\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f4\Include; ..\..\..\..\3rd-party\middlewares\freertos\include\; ..\..\..\..\3rd-party\middlewares\freertos\portable\IAR\ARM_CM4F\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\telnetd\
configuration smtp (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; UIP_EXAMPLE_SMTP
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\hal\inc\hal-lan8720-rmii\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\lan8720\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\platform\stm32f407zg\freertos\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f4\Include; ..\..\..\..\3rd-party\middlewares\freertos\include\; ..\..\..\..\3rd-party\middlewares\freertos\portable\IAR\ARM_CM4F\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\smtp\
configuration resolv (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; UIP_EXAMPLE_RESOLV
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\hal\inc\hal-lan8720-rmii\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\lan8720\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\platform\stm32f407zg\freertos\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f4\Include; ..\..\..\..\3rd-party\middlewares\freertos\include\; ..\..\..\..\3rd-party\middlewares\freertos\portable\IAR\ARM_CM4F\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\resolv\; ..\..\..\..\3rd-party\middlewares\uip\apps\webclient\
configuration webclient (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; UIP_EXAMPLE_WEBCLIENT
  ICCARM.CCIncludePath2: as above
configuration webserver (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; UIP_EXAMPLE_WEBSERVER
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\hal\inc\hal-lan8720-rmii\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\lan8720\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\platform\stm32f407zg\freertos\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f4\Include; ..\..\..\..\3rd-party\middlewares\freertos\include\; ..\..\..\..\3rd-party\middlewares\freertos\portable\IAR\ARM_CM4F\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\webserver\
  group Project
    ../../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f407zg/: compiler-def.h cpu.h stm32f4xx-hw.c stm32f4xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f4/Source/Templates/iar/: startup_stm32f407xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f4/Source/Templates/: system_stm32f4xx.c
  group Project/drv
    ../../../../drv/ethernet/eth-uip/: eth-uip-freertos.c eth-uip-lan8720-drv.c
  group Project/hal
    ../../../../hal/src/stm32f407zg/: hal-lan8720-rmii.c
    ../../../../hal/inc/hal-lan8720-rmii/: lan8720-regs.h mac.h
  group Project/middlewares/freertos
    ../../../../platform/stm32f407zg/freertos/: FreeRTOSConfig.h
    ../../../../3rd-party/middlewares/freertos/portable/MemMang/: heap_4.c
    ../../../../3rd-party/middlewares/freertos/: list.c queue.c tasks.c
  group Project/middlewares/freertos/cortex-m4f
    ../../../../3rd-party/middlewares/freertos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Project/middlewares/uip
    ../../../../3rd-party/middlewares/uip/: psock.c timer.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group Project/middlewares/uip/apps/dhcpc
    ../../../../3rd-party/middlewares/uip/apps/dhcpc/: dhcpc.c
  group Project/middlewares/uip/apps/hello-world
    ../../../../3rd-party/middlewares/uip/apps/hello-world/: hello-world.c
  group Project/middlewares/uip/apps/resolv
    ../../../../3rd-party/middlewares/uip/apps/resolv/: resolv.c
  group Project/middlewares/uip/apps/smtp
    ../../../../3rd-party/middlewares/uip/apps/smtp/: smtp-strings.c smtp.c
  group Project/middlewares/uip/apps/telnetd
    ../../../../3rd-party/middlewares/uip/apps/telnetd/: memb.c shell.c telnetd.c
  group Project/middlewares/uip/apps/webclient
    ../../../../3rd-party/middlewares/uip/apps/webclient/: webclient-strings.c webclient.c
  group Project/middlewares/uip/apps/webserver
    ../../../../3rd-party/middlewares/uip/apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
  group Project/middlewares/uip/port
    ../../../../lib/uip/: clock-arch.c
  group Project/platform
    ../../../../platform/stm32f407zg/: platform-freertos.c
