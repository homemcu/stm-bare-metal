<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\plain.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uip-freertos.ewp</path>
  </project>
  <batchBuild/>
</workspace>


