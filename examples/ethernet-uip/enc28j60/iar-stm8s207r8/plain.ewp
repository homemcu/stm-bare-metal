# IAR project plain.ewp, settings and files
configuration hello-world (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207; UIP_EXAMPLE_HELLO_WORLD; UIP_CONF_BYTE_ORDER=UIP_BIG_ENDIAN
  ICCSTM8.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\enc28j60\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\hello-world\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration dhcpc (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S207; UIP_EXAMPLE_DHCPC; UIP_CONF_BYTE_ORDER=UIP_BIG_ENDIAN
  ICCSTM8.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\enc28j60\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\dhcpc\; ..\..\..\..\3rd-party\middlewares\uip\apps\telnetd\
configuration telnetd (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S207; UIP_EXAMPLE_TELNETD; UIP_CONF_BYTE_ORDER=UIP_BIG_ENDIAN
  ICCSTM8.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\enc28j60\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\telnetd\
configuration smtp (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S207; UIP_EXAMPLE_SMTP; UIP_CONF_BYTE_ORDER=UIP_BIG_ENDIAN
  ICCSTM8.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\enc28j60\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\smtp\
configuration resolv (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S207; UIP_EXAMPLE_RESOLV; UIP_CONF_BYTE_ORDER=UIP_BIG_ENDIAN
  ICCSTM8.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\enc28j60\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\resolv\; ..\..\..\..\3rd-party\middlewares\uip\apps\webclient\
configuration webclient (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S207; UIP_EXAMPLE_WEBCLIENT; UIP_CONF_BYTE_ORDER=UIP_BIG_ENDIAN
  ICCSTM8.CCIncludePath2: as above
configuration webserver (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S207; UIP_EXAMPLE_WEBSERVER; UIP_CONF_BYTE_ORDER=UIP_BIG_ENDIAN
  ICCSTM8.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\drv\ethernet\enc28j60\; ..\..\..\..\lib\uip\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\webserver\
  group Project
    ../../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm8s207r8/: compiler-def.h cpu.h stm8.h
  group Project/drv
    ../../../../drv/ethernet/enc28j60/: enc28j60.c
    ../../../../drv/ethernet/eth-uip/: eth-uip-enc28j60-drv.c eth-uip-plain.c
  group Project/hal
    ../../../../hal/src/stm8s207r8/: hal-enc28j60.c
  group Project/middlewares/uip
    ../../../../3rd-party/middlewares/uip/: psock.c timer.c uip-fw.c uip-neighbor.c uip.c uip_arp.c uiplib.c
  group Project/middlewares/uip/apps/dhcpc
    ../../../../3rd-party/middlewares/uip/apps/dhcpc/: dhcpc.c
  group Project/middlewares/uip/apps/hello-world
    ../../../../3rd-party/middlewares/uip/apps/hello-world/: hello-world.c
  group Project/middlewares/uip/apps/resolv
    ../../../../3rd-party/middlewares/uip/apps/resolv/: resolv.c
  group Project/middlewares/uip/apps/smtp
    ../../../../3rd-party/middlewares/uip/apps/smtp/: smtp-strings.c smtp.c
  group Project/middlewares/uip/apps/telnetd
    ../../../../3rd-party/middlewares/uip/apps/telnetd/: memb.c shell.c telnetd.c
  group Project/middlewares/uip/apps/webclient
    ../../../../3rd-party/middlewares/uip/apps/webclient/: webclient-strings.c webclient.c
  group Project/middlewares/uip/apps/webserver
    ../../../../3rd-party/middlewares/uip/apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
  group Project/middlewares/uip/port
    ../../../../lib/uip/: clock-arch.c
  group Project/platform
    ../../../../platform/stm8s207r8/: platform.c
