# IAR project plain.ewp, settings and files
configuration spi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; ILI9341_SPI
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\imgsensor\; ..\..\..\..\drv\imgsensor\ov7670\; ..\..\..\..\drv\color-scr\; ..\..\..\..\drv\color-scr\ili9341\; ..\..\..\..\lib\screen\; ..\..\..\..\lib\screen\color-scr\; ..\..\..\..\lib\fonts\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f4\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration fsmc (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; ILI9341_8080I
  group Project
    ../../src/: main-row.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f407zg/: compiler-def.h cpu.h stm32f4xx-hw.c stm32f4xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f4/Source/Templates/iar/: startup_stm32f407xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f4/Source/Templates/: system_stm32f4xx.c
  group Project/drv
    ../../../../drv/color-scr/: color-scr-ili9341-drv.c
    ../../../../drv/color-scr/ili9341/: ili9341.c
    ../../../../drv/imgsensor/: imgsensor-ov7670-drv.c
    ../../../../drv/imgsensor/ov7670/: ov7670.c
  group Project/hal
    ../../../../hal/src/stm32f407zg/: hal-ili9341-4line-spi.c hal-ili9341-8080I-16bit-fsmc.c hal-imgsensor-dcmi.c hal-imgsensor-i2c_ov7670_ov7725.c
  group Project/lib
    ../../../../lib/screen/color-scr/: color-scr.c
    ../../../../lib/fonts/: fonts.c
  group Project/platform
    ../../../../platform/stm32f407zg/: platform.c
