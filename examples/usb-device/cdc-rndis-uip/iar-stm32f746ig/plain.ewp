# IAR project plain.ewp, settings and files
configuration cdc-rndis-uip-otgfs (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGFS; UIP_EXAMPLE_HELLO_WORLD
  ICCARM.CCIncludePath2: ..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\ethernet\; ..\..\..\..\drv\ethernet\eth-uip\; ..\..\..\..\lib\uip; ..\..\..\..\lib\usbd\class; ..\..\..\..\lib\usbd\rndis; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f7\Include; ..\..\..\..\3rd-party\drivers\libusb_stm32\inc\; ..\..\..\..\3rd-party\middlewares\uip\; ..\..\..\..\3rd-party\middlewares\uip\apps\hello-world\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration cdc-rndis-uip-otghs-fs (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS_FS; UIP_EXAMPLE_HELLO_WORLD
configuration cdc-rndis-uip-otghs-ulpi-fs (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS_FS; USBD_ULPI; UIP_EXAMPLE_HELLO_WORLD
configuration cdc-rndis-uip-otghs-ulpi-hs (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS; USBD_ULPI; UIP_EXAMPLE_HELLO_WORLD
  group Project
    ../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/: system_stm32f7xx.c
  group Project/drv
    ../../../../drv/ethernet/eth-uip/: eth-uip-plain_rndis.c eth-uip-rndis-drv.c
  group Project/hal
    ../../../../hal/src/stm32f746ig/: hal-usbd-init.c
  group Project/lib
    ../../../../lib/usbd/rndis/: usb-cdc-rndis.c
  group Project/middlewares/libusb
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_core.c
  group Project/middlewares/libusb/dev
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_stm32f746_otgfs.c usbd_stm32f746_otghs.c
  group Project/middlewares/uip
    ../../../../3rd-party/middlewares/uip/: psock.c timer.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group Project/middlewares/uip/apps/hello-world
    ../../../../3rd-party/middlewares/uip/apps/hello-world/: hello-world.c
  group Project/middlewares/uip/port
    ../../../../lib/uip/: clock-arch.c
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
