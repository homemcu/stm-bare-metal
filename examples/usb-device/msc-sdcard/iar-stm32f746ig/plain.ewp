# IAR project plain.ewp, settings and files
configuration msc-otghs-fs-sdmmc-sdcard (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS_FS
  ICCARM.CCIncludePath2: ..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\sd-card\; ..\..\..\..\lib\usbd\class\; ..\..\..\..\lib\usbd\msc-sdcard\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f7\Include; ..\..\..\..\3rd-party\drivers\libusb_stm32\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration msc-otghs-fs-spi-sdcard (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\sd-card\; ..\..\..\..\drv\sd-card\sd-spi\; ..\..\..\..\lib\usbd\class\; ..\..\..\..\lib\usbd\msc-sdcard\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f7\Include; ..\..\..\..\3rd-party\drivers\libusb_stm32\inc\
configuration msc-otgfs-sdmmc-sdcard (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGFS
configuration msc-otgfs-spi-sdcard (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGFS
  ICCARM.CCIncludePath2: as above
configuration msc-otghs-ulpi-fs-spi-sdcard (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS_FS; USBD_ULPI
  ICCARM.CCIncludePath2: as above
configuration msc-otghs-ulpi-fs-sdmmc-sdcard (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS_FS; USBD_ULPI
configuration msc-otghs-ulpi-hs-spi-sdcard (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS; USBD_ULPI
  ICCARM.CCIncludePath2: as above
configuration msc-otghs-ulpi-hs-sdmmc-sdcard (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; USBD_OTGHS; USBD_ULPI
  group Project
    ../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/: system_stm32f7xx.c
  group Project/drv
    ../../../../drv/sd-card/: sd-card-sdmmc-drv.c sd-card-spi-drv.c
    ../../../../drv/sd-card/sd-spi/: sd-spi.c
  group Project/hal
    ../../../../hal/src/stm32f746ig/: hal-sd-sdmmc.c hal-sd-spi.c hal-usbd-init.c
  group Project/lib
    ../../../../lib/usbd/msc-sdcard/: usb-msc-bot-scsi.c
  group Project/middlewares/libusb
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_core.c
  group Project/middlewares/libusb/dev
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_stm32f746_otgfs.c usbd_stm32f746_otghs.c
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
