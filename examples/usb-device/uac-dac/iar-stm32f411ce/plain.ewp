# IAR project plain.ewp, settings and files
configuration uac-otgfs-spi-i2s (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE; HSE_VALUE=25000000; USBD_OTGFS
  ICCARM.CCIncludePath2: ..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\audio-out\; ..\..\..\..\lib\usbd\class\; ..\..\..\..\lib\usbd\uac-dac\; ..\..\..\..\cpu\stm32f411ce\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f4\Include; ..\..\..\..\3rd-party\drivers\libusb_stm32\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f411ce/: compiler-def.h cpu.h stm32f4xx-hw.c stm32f4xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f4/Source/Templates/iar/: startup_stm32f411xe.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f4/Source/Templates/: system_stm32f4xx.c
  group Project/drv
    ../../../../drv/audio-out/: uac-dac-spi-i2s-drv.c
  group Project/hal
    ../../../../hal/src/stm32f411ce/: hal-i2s-mclk.c hal-spi-i2s.c hal-usbd-init.c
  group Project/lib
    ../../../../lib/usbd/uac-dac/: usb-uac-i2s.c
  group Project/middlewares/libusb
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_core.c
  group Project/middlewares/libusb/dev
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_stm32f429_otgfs.c
  group Project/platform
    ../../../../platform/stm32f411ce/: platform.c
