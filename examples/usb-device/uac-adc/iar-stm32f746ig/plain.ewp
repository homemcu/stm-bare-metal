# IAR project plain.ewp, settings and files
configuration uac-otgfs-spi-i2s (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; UART_TERMINAL=1; USBD_OTGFS
  ICCARM.CCIncludePath2: ..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\audio-in\; ..\..\..\..\lib\usbd\class\; ..\..\..\..\lib\usbd\uac-adc\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f7\Include; ..\..\..\..\3rd-party\drivers\libusb_stm32\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration uac-otgfs-sai-i2s (ARM, debug)
  as the first configuration, except:
configuration uac-otghs-fs-spi-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; UART_TERMINAL=1; USBD_OTGHS_FS
configuration uac-otghs-fs-sai-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
configuration uac-otghs-ulpi-fs-spi-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; UART_TERMINAL=1; USBD_OTGHS_FS; USBD_ULPI
configuration uac-otghs-ulpi-fs-sai-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
configuration uac2-otghs-ulpi-hs-spi-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; UART_TERMINAL=1; USBD_OTGHS
configuration uac2-otghs-ulpi-hs-sai-i2s (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; UART_TERMINAL=1; USBD_OTGHS; USBD_ULPI
  group Project
    ../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f7/Source/Templates/: system_stm32f7xx.c
  group Project/drv
    ../../../../drv/audio-in/: uac-adc-sai-i2s-drv.c uac-adc-spi-i2s-drv.c uac2-adc-sai-i2s-drv.c uac2-adc-spi-i2s-drv.c
  group Project/hal
    ../../../../hal/src/stm32f746ig/: hal-sai-i2s.c hal-spi-i2s.c hal-usbd-init.c
  group Project/lib
    ../../../../lib/usbd/uac-adc/: usb-uac-i2s.c usb-uac2-i2s.c
  group Project/middlewares/libusb
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_core.c
  group Project/middlewares/libusb/dev
    ../../../../3rd-party/drivers/libusb_stm32/src/: usbd_stm32f746_otgfs.c usbd_stm32f746_otghs.c
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
