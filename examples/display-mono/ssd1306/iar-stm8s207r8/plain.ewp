# IAR project plain.ewp, settings and files
configuration i2c (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207; SSD1306_128_32
  ICCSTM8.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\mono-scr\; ..\..\..\..\drv\mono-scr\ssd1306\; ..\..\..\..\lib\screen\; ..\..\..\..\lib\screen\mono-scr\; ..\..\..\..\lib\fonts\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 4line-spi (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S207; SSD1306_128_64
  group Project
    ../../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm8s207r8/: compiler-def.h cpu.h stm8.h
  group Project/drv
    ../../../../drv/mono-scr/: mono-scr-ssd1306-drv.c
    ../../../../drv/mono-scr/ssd1306/: ssd1306.c
  group Project/hal
    ../../../../hal/src/stm8s207r8/: hal-ssd1306-4line-spi.c hal-ssd1306-i2c.c
  group Project/lib
    ../../../../lib/fonts/: fonts.c
    ../../../../lib/screen/mono-scr/: mono-scr.c
  group Project/platform
    ../../../../platform/stm8s207r8/: platform.c
