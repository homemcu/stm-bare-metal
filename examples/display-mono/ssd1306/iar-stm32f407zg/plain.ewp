# IAR project plain.ewp, settings and files
configuration i2c (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; SSD1306_128_32
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\mono-scr\; ..\..\..\..\drv\mono-scr\ssd1306\; ..\..\..\..\lib\screen\; ..\..\..\..\lib\screen\mono-scr\; ..\..\..\..\lib\fonts\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f4\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 4line-spi (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; SSD1306_128_64
  group Project
    ../../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f407zg/: compiler-def.h cpu.h stm32f4xx-hw.c stm32f4xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f4/Source/Templates/iar/: startup_stm32f407xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f4/Source/Templates/: system_stm32f4xx.c
  group Project/drv
    ../../../../drv/mono-scr/: mono-scr-ssd1306-drv.c
    ../../../../drv/mono-scr/ssd1306/: ssd1306.c
  group Project/hal
    ../../../../hal/src/stm32f407zg/: hal-ssd1306-4line-spi.c hal-ssd1306-i2c.c
  group Project/lib
    ../../../../lib/fonts/: fonts.c
    ../../../../lib/screen/mono-scr/: mono-scr.c
  group Project/platform
    ../../../../platform/stm32f407zg/: platform.c
