# IAR project plain.ewp, settings and files
configuration spi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\..\src\; ..\..\..\..\hal\inc\; ..\..\..\..\drv\flash\; ..\..\..\..\drv\flash\w25q\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\cmsis_device_f4\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\; ..\..\middlewares\freertos\include\; ..\..\middlewares\freertos\portable\IAR\ARM_CM4F\
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../../src/: main.c project-conf.h
  group Project/cpu
    ../../../../cpu/stm32f407zg/: compiler-def.h cpu.h stm32f4xx-hw.c stm32f4xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f4/Source/Templates/iar/: startup_stm32f407xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/cmsis_device_f4/Source/Templates/: system_stm32f4xx.c
  group Project/drv
    ../../../../drv/flash/: spi-flash-w25q-drv.c
    ../../../../drv/flash/w25q/: w25q.c
  group Project/hal
    ../../../../hal/src/stm32f407zg/: hal-w25q-spi.c
  group Project/platform
    ../../../../platform/stm32f407zg/: platform.c
