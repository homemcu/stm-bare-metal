# IAR project plain.ewp, settings and files
configuration spi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; ILI9341_SPI
  ICCARM.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\src\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration fsmc (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; ILI9341_8080I
  group Project
    ../../src/: color-scr-drv.h color-scr-ili9341-drv.c color-scr.c color-scr.h fonts.c fonts.h main-touch.c rgb565-colors.h rgb666-colors.h touch-xpt2046-drv.c touch.c touch.h
  group Project/cpu
    ../../../../cpu/stm32f407zg/: compiler-def.h cpu.h stm32f4xx-hw.c stm32f4xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Project/dev
    ../src/dev/: hal-ili9341.h hal-xpt2046.h ili9341-cmds.h ili9341.c ili9341.h xpt2046-cmds.h xpt2046.c xpt2046.h
  group Project/platform
    ../../../../platform/stm32f407zg/: platform.c
  group Project/platform/dev
    ../src/platform/stm32f407zg/dev/: hal-ili9341-4line-spi.c hal-ili9341-8080I-16bit-fsmc.c hal-xpt2046-soft-spi.c
