# IAR project plain.ewp, settings and files
configuration spi (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\src\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../../src/: color-scr-drv.h color-scr-st7735-drv.c color-scr.c color-scr.h fonts.c fonts.h main.c rgb565-colors.h rgb666-colors.h
    ../../../../platform/: platform.h
  group Project/cpu
    ../../../../cpu/stm8s207r8/: compiler-def.h cpu.h stm8.h
  group Project/dev
    ../src/dev/: hal-st7735.h st7735-cmds.h st7735.c st7735.h
  group Project/platform
    ../../../../platform/stm8s207r8/: platform.c
  group Project/platform/dev
    ../src/platform/stm8s207r8/dev/: hal-st7735-4line-spi.c
