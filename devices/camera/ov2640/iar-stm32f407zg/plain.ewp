# IAR project plain.ewp, settings and files
configuration spi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; ILI9341_SPI
  ICCARM.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\src\; ..\..\..\display-color\ili9341+xpt2046\src\dev\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration fsmc (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; ILI9341_8080I
  group Project
    ../../src/: color-scr-drv.h color-scr-ili9341-drv.c color-scr.c fonts.c imgsensor-drv.h imgsensor-ov2640-drv.c main-row.c
  group Project/cpu
    ../../../../cpu/stm32f407zg/: compiler-def.h cpu.h stm32f4xx-hw.c stm32f4xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Project/dev
    ../../../display-color/ili9341+xpt2046/src/dev/: hal-ili9341.h ili9341-cmds.h ili9341.c ili9341.h
    ../src/dev/: hal-imgsensor-dcmi.h hal-imgsensor-i2c.h ov2640-cmds.h ov2640.c ov2640.h scr.h
  group Project/platform
    ../../../../platform/stm32f407zg/: platform.c
  group Project/platform/dev
    ../../../display-color/ili9341+xpt2046/src/platform/stm32f407zg/dev/: hal-ili9341-4line-spi.c hal-ili9341-8080I-16bit-fsmc.c
    ../src/platform/stm32f407zg/dev/: hal-imgsensor-dcmi.c hal-imgsensor-i2c.c
