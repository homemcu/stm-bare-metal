# IAR project plain.ewp, settings and files
configuration spi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; ILI9341_SPI; UART_TERMINAL=1
  ICCARM.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\src\; ..\..\..\display-color\ili9341+xpt2046\src\dev\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F7xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration fmc (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; ILI9341_8080I; UART_TERMINAL=1
  group Project
    ../../src/: color-scr-drv.h color-scr-ili9341-drv.c color-scr.c fonts.c imgsensor-drv.h imgsensor-ov7725-drv.c main-frame.c
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Project/dev
    ../../../display-color/ili9341+xpt2046/src/dev/: hal-ili9341.h ili9341-cmds.h ili9341.c ili9341.h
    ../src/dev/: hal-imgsensor-dcmi.h hal-imgsensor-i2c.h ov7725-cmds.h ov7725.c ov7725.h
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
  group Project/platform/dev
    ../../../display-color/ili9341+xpt2046/src/platform/stm32f746ig/dev/: hal-ili9341-4line-spi.c hal-ili9341-8080I-16bit-fmc.c
    ../src/platform/stm32f746ig/dev/: hal-imgsensor-dcmi.c hal-imgsensor-i2c.c
