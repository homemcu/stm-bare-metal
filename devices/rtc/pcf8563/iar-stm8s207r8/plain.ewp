# IAR project plain.ewp, settings and files
configuration i2c-terminal (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\src\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\middlewares\xprintf\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration i2c-uart (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S207; UART_TERMINAL=1
  group Project
    ../../src/: main.c rtc-drv.h rtc-pcf8563-drv.c rtc-time.h
  group Project/cpu
    ../../../../cpu/stm8s207r8/: compiler-def.h cpu.h stm8.h
  group Project/dev
    ../src/dev/: hal-pcf8563.h pcf8563-regs.h pcf8563.c pcf8563.h
  group Project/middlewares/xprintf
    ../../../../3rd-party/middlewares/xprintf/: xprintf.c xprintf.h
  group Project/platform
    ../../../../platform/stm8s207r8/: platform.c
  group Project/platform/dev
    ../src/platform/stm8s207r8/dev/: hal-pcf8563-i2c.c
