# IAR project plain.ewp, settings and files
configuration spi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; UART_TERMINAL=7
  ICCARM.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\src\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F7xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sdmmc (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; HSE_VALUE=8000000; DUART_TERMINAL=7
  ICCARM.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\src\; ..\..\..\display-color\ili9341+xpt2046\src\dev\; ..\..\..\..\cpu\stm32f746ig\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F7xx\Include
  group Project
    ../../src/: main.c sd-card-drv.h sd-card-sdmmc-drv.c sd-card-spi-drv.c
  group Project/cpu
    ../../../../cpu/stm32f746ig/: compiler-def.h cpu.h stm32f7xx-hw.c stm32f7xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Project/dev
    ../src/dev/: hal-sd-sdmmc.h hal-sd-spi.h sd-defs.h sd-spi.c sd-spi.h sd.h
  group Project/platform
    ../../../../platform/stm32f746ig/: platform.c
  group Project/platform/dev
    ../src/platform/stm32f746ig/dev/: hal-sd-sdmmc.c hal-sd-spi.c
