# IAR project plain.ewp, settings and files
configuration sdio (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\src\; ..\..\src\fatfs\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F4xx\Include; ..\..\..\..\3rd-party\middlewares\fatfs\source\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\platform\stm32f407zg\; ..\..\middlewares\freertos\include\; ..\..\middlewares\freertos\portable\IAR\ARM_CM4F\
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration spi (ARM, debug)
  as the first configuration, except:
  group Project
    ../../src/: main.c sd-card-drv.h sd-card-sdio-drv.c sd-card-spi-drv.c
  group Project/cpu
    ../../../../cpu/stm32f407zg/: compiler-def.h cpu.h stm32f4xx-hw.c stm32f4xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Project/dev
    ../src/dev/: hal-sd-sdio.h hal-sd-spi.h sd-spi.c sd-spi.h
  group Project/platform
    ../../../../platform/stm32f407zg/: platform.c
  group Project/platform/dev
    ../src/platform/stm32f407zg/dev/: hal-sd-sdio.c hal-sd-spi.c
