# IAR project plain.ewp, settings and files
configuration i2c (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207; SSD1306_128_32
  ICCSTM8.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\src\; ..\..\..\..\cpu\stm8s207r8\; ..\..\..\..\platform\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 4line-spi (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S207; SSD1306_128_64
  group Project
    ../../src/: fonts.c fonts.h main.c mono-scr-drv.h mono-scr-ssd1306-drv.c mono-scr.c mono-scr.h
  group Project/cpu
    ../../../../cpu/stm8s207r8/: compiler-def.h cpu.h stm8.h
  group Project/dev
    ../src/dev/: hal-ssd1306.h scr.h ssd1306-cmds.h ssd1306.c ssd1306.h
  group Project/platform
    ../../../../platform/stm8s207r8/: platform.c
  group Project/platform/dev
    ../src/platform/stm8s207r8/dev/: hal-ssd1306-4line-spi.c hal-ssd1306-i2c.c
