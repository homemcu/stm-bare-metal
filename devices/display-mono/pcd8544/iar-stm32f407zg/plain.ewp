# IAR project plain.ewp, settings and files
configuration spi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\src\; ..\src\dev\; ..\..\src\; ..\..\..\..\cpu\stm32f407zg\; ..\..\..\..\platform\; ..\..\..\..\3rd-party\drivers\cmsis\core\; ..\..\..\..\3rd-party\drivers\cmsis\device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: plain.hex
  ILINK.IlinkOutputFile: plain.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../../src/: fonts.c fonts.h main.c mono-scr-drv.h mono-scr-pcd8544-drv.c mono-scr.c mono-scr.h
  group Project/cpu
    ../../../../cpu/stm32f407zg/: compiler-def.h cpu.h stm32f4xx-hw.c stm32f4xx-hw.h
  group Project/cpu/cmsis
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../../../../3rd-party/drivers/cmsis/device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Project/dev
    ../src/dev/: hal-pcd8544.h pcd8544-cmds.h pcd8544.c pcd8544.h scr.h
  group Project/platform
    ../../../../platform/stm32f407zg/: platform.c
  group Project/platform/dev
    ../src/platform/stm32f407zg/dev/: hal-pcd8544.c
